# Keil uVision project Bootloader.uvprojx, settings and files
target Nucleo-F411RE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Include;..\Drivers\HAL\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User
    ../src/: Bootloader.c
  group Driver/CMSIS
    ./: startup_stm32f411xe.s system_stm32f4xx.c
  group Driver/HAL
    ../Drivers/HAL/Include/: HAL_GPIO_Driver.h HAL_Common.h HAL_CRC_Driver.h HAL_UART_Driver.h HAL_RCC_Driver.h HAL_Flash_Driver.h
    ../Drivers/HAL/Source/: HAL_GPIO_Driver.c HAL_CRC_Driver.c HAL_UART_Driver.c HAL_RCC_Driver.c HAL_Flash_Driver.c
software components: CMSIS:CORE 5.0.2
